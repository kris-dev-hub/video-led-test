## esp32smini-test/app/sdkconfig.defaults
```kconfig
# ESP32-S3-Zero specific configuration
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
CONFIG_PARTITION_TABLE_SINGLE_APP=y
```
